# IAR project Project.ewp, settings and files
configuration STM8S103 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..\..; ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\User\bsp; ..\..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: cmd /c "del "$OBJ_DIR$\*.o""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp_lcd.c bsp_lcd.h
  group StdPeriph_Drivers
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c
  group User
    ../../User/: main.c stm8s_it.c
